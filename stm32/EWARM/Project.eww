<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\demo_ads1293.ewp</path>
  </project>
  <batchBuild />
</workspace>
